# Keil uVision project main.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  AfterMake: keil-build-viewer.exe -NOPATH
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: -Wno-incompatible-pointer-types -Wno-int-conversion
  c include: ..\Library\CMSIS\startup;..\Library\FWlib\inc;..\Library\FWlib\src;..\Library\CMSIS;..\Project;..\USER\Bsp;..\USER\Bsp\Led;..\USER\Bsp\Key;..\USER\Bsp\Usart;..\USER\utilities;..\USER\app;..\USER\Bsp\time;..\..\src\common\block;..\..\src\common\byte_fifo;..\..\src\zero_strm;..\..\src\zero_strm\zero_strm_read;..\..\src\zero_strm\zero_strm_write
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: main.sct
  group User
    ./: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../Library/CMSIS/startup/: startup_stm32f10x_hd.s
  group Bsp
    ../USER/Bsp/: bsp.c
    ../USER/Bsp/Led/: bsp_led.c
    ../USER/Bsp/Key/: bsp_key.c
    ../USER/Bsp/Usart/: bsp_uart.c
    ../USER/Bsp/time/: bsp_timer.c
  group Core
    ../Library/CMSIS/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group ST32
    ../Library/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group zero_strm_block
    ../../src/common/block/: app_cfg.h zero_strm_block.c zero_strm_block.h
  group zero_strm_byte_fifo
    ../../src/common/byte_fifo/: app_cfg.h zero_strm_byte_fifo.c zero_strm_byte_fifo.h
  group zero_strm
    ../../src/zero_strm/: zero_strm.h zero_strm_cfg.h
    ../../src/zero_strm/zero_strm_read/: zero_strm_read.c zero_strm_read.h fsm_dequeue.c fsm_dequeue.h
    ../../src/zero_strm/zero_strm_write/: zero_strm_write.c zero_strm_write.h fsm_enqueue.c fsm_enqueue.h
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 5.6.0, Utilities:perf_counter:Core 2.3.1
